FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://kata-config.cfg "