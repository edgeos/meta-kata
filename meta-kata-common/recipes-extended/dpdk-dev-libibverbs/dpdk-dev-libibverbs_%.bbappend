
# Not sure which is the correct way...
COMPATIBLE_MACHINE = "${MACHINE}"
# COMPATIBLE_MACHINE_qemux86-64 = "qemux86-64"
