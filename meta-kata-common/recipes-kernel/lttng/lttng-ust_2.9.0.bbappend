SYSROOT_DIRS += " ${bindir} "
